# Keil uVision project Lab3.uvprojx, settings and files
target Lab3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab3Main.c SwitchDriver.c SwitchDriver.h LCDDriver.c LCDDriver.h SysTickDriver.c SysTickDriver.h SoundDriver.c SoundDriver.h
    ../inc/: PLL.c Timer0A.c ST7735.c Timer1A.c
software components: CMSIS:CORE 6.1.0
